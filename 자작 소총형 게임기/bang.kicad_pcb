# Repository ksk1059/-

## KiCad design 자작 소총형 게임기/bang.kicad_pcb

File 자작 소총형 게임기/README.md:

# 자작 소총형 게임기 (bang)

부스 홍보용 레일 슈터 게임에 쓰는 소총 모양 컨트롤러의 KiCad 프로젝트.

- MCU: ESP32-S3-WROOM-1 / 조준: BNO085 IMU
- 입력: 방아쇠, 탄창 탈착 장전(홀 센서), 노리쇠 당김
- 진동 모터(AO3400A MOSFET 구동)
- 화면: 총에 단 폰으로 PC 화면 무선 스트리밍

## 폴더
- `bang.kicad_pro / .kicad_sch / .kicad_pcb` — 프로젝트·회로도·PCB
- `lib/` — LCSC 부품 심볼·풋프린트·3D 모델
- `gerber/`, `jlc/` — JLCPCB 제작용 거버, BOM/CPL
- `stencil_home/` — 집 리플로우용 스텐실
- `drc/`, `erc/` — 검사 리포트
- `test_fw/` — 테스트 펌웨어(Arduino)

Parts:
C1, C8: 10uF 25V X5R; C_0805_2012Metric; LCSC Part C15850
C2, C3: 22uF 25V X5R; C_1206_3216Metric; LCSC Part C12891
C4, C6, C7, C9, C16: 100nF 16V X7R; C_0402_1005Metric; LCSC Part C1525
C5: 1uF 50V X5R; C_0603_1608Metric; LCSC Part C15849
C10, C11: 22pF 50V C0G; C_0402_1005Metric; LCSC Part C1555
D1: B5819W SL (1A Schottky); SOD-123_L2.7-W1.6-LS3.7-RD-1; LCSC Part C8598
D2: RED; LED_0603_1608Metric; LCSC Part C2286
J1: USB-C (TYPE-C-31-M-12); USB-C_SMD-TYPE-C-31-M-12_1; LCSC Part C165948
J2: TRIG (JST-PH 3P); CONN-TH_B3B-PH-K-S; LCSC Part C131339
J3: MAG (JST-PH 3P); CONN-TH_B3B-PH-K-S; LCSC Part C131339
J4: BOLT (JST-PH 3P); CONN-TH_B3B-PH-K-S; LCSC Part C131339
J5: RECENTER (JST-PH 3P); CONN-TH_B3B-PH-K-S; LCSC Part C131339
J6: Qwiic I2C (GND,3V3,SDA,SCL); CONN-SMD_4P-P1.00_SM04B-SRSS-TB-LF-SN; LCSC Part C160404
J7: MOTOR (JST-PH 2P); CONN-TH_B2B-PH-K-S; LCSC Part C5251182
J8: FPV 5V OUT (JST-PH 2P); CONN-TH_B2B-PH-K-S; LCSC Part C5251182
Q1: AO3400A; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C20917
R1, R2: 5.1k; R_0402_1005Metric; LCSC Part C25905
R3, R4, R5, R6, R7, R8, R9, R10, R13, R14, R15, R16, R18: 10k; R_0402_1005Metric; LCSC Part C25744
R11, R12: 2.2k; R_0402_1005Metric; LCSC Part C25879
R17, R19: 1k; R_0402_1005Metric; LCSC Part C11702
SW1: RESET; SW-SMD_L3.9-W3.0-P4.45; LCSC Part C455280
SW2: BOOT; SW-SMD_L3.9-W3.0-P4.45; LCSC Part C455280
U1: ESP32-S3-WROOM-1-N8; WIFIM-SMD_ESP32-S3-WROOM-1-N8; LCSC Part C2913198
U2: BNO085; LGA-28_L5.2-W3.8-P0.50-BL; LCSC Part C5189642
U3: AMS1117-3.3; SOT-223-3_L6.5-W3.4-P2.30-LS7.0-BR; LCSC Part C6186
U4: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; LCSC Part C7519
Y1: 32.768kHz 12.5pF; FC-135R_L3.2-W1.5; LCSC Part C32346

Connections:
+3V3: C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, J2.1, J4.1, J5.1, J6.2, R3.1, R4.1, R5.1, R6.1, R7.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, U1.2 (3V3), U2.3 (VDD), U2.28 (VDDIO), U3.2 (VOUT), U3.4 (VOUT)
+5V: C1.1, C16.1, D1.1 (-), J1.A4B9 (VBUS), J1.B4A9 (VBUS), J3.1, J7.1, J8.1, U3.3 (VIN), U4.5
BOLT: J4.3, R15.2, U1.6 (IO6)
BOOT: R4.2, SW2.1, U1.27 (IO0)
EN: C5.1, R3.2, SW1.1, U1.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C16.2, D2.1 (K), J1.1 (EH), J1.2 (EH), J1.3 (EH), J1.4 (EH), J1.A1B12 (GND), J1.B1A12 (GND), J2.2, J3.2, J4.2, J5.2, J6.1, J6.5, J6.6, J8.2, Q1.2 (S), R1.2, R2.2, R8.2, R18.2, SW1.2, SW2.2, U1.1 (GND), U1.40 (GND), U1.41 (EP), U2.2 (GND), U2.5 (PS1), U2.6 (PS0/WAKE), U2.10 (CLKSEL0), U2.25 (GND), U3.1 (GND), U4.2
I2C_SCL: J6.4, R11.2, U1.17 (IO9), U2.19 (H_SCL/SCK/RX)
I2C_SDA: J6.3, R12.2, U1.12 (IO8), U2.20 (H_SDA/H_MISO/TX)
IMU_BOOTN: R5.2, U2.4 (BOOTN)
IMU_CAP: C9.1, U2.9 (CAP)
IMU_CSN: R7.2, U2.18 (H_CSN)
IMU_ENV_SCL: R9.2, U2.15 (ENV_SCL)
IMU_ENV_SDA: R10.2, U2.16 (ENV_SDA)
IMU_INT: U1.18 (IO10), U2.14 (H_INTN)
IMU_RST: R6.2, U1.19 (IO11), U2.11 (NRST)
IMU_SA0: R8.1, U2.17 (SA0/H_MOSI)
IMU_XIN: C10.1, U2.27 (XIN32), Y1.1
IMU_XOUT: C11.1, U2.26 (XOUT32/CLKSEL1), Y1.2
LED_A: D2.2 (A), R19.2
LED_STAT: R19.1, U1.21 (IO13)
MAG: J3.3, R14.2, U1.5 (IO5)
MOTOR_G: Q1.1 (G), R17.2, R18.1
MOTOR_N: D1.2 (+), J7.2, Q1.3 (D)
MOTOR_PWM: R17.1, U1.20 (IO12)
RECENTER: J5.3, R16.2, U1.7 (IO7)
TRIG: J2.3, R13.2, U1.4 (IO4)
USB_CC1: J1.A5 (CC1), R1.1
USB_CC2: J1.B5 (CC2), R2.1
USB_D_N: J1.A7 (DN1), J1.B7 (DN2), U1.13 (IO19), U4.1, U4.6
USB_D_P: J1.A6 (DP1), J1.B6 (DP2), U1.14 (IO20), U4.3, U4.4

Notes on the sheet:
[출력] 진동모터 KOTL Z7AL2B1690002 (LCSC C2894723, 3V 250mA, LCSC 별도주문→JLC 합배송) → 5V에서 PWM 듀티 ≤60% / FPV 모니터 5V 공급 / 상태 LED
[MCU] ESP32-S3-WROOM-1-N8 (PSRAM 없음) — IO26~32는 내부 플래시용이라 모듈 핀에 없음
[IMU] BNO085 — I2C 모드(PS0=PS1=GND), 주소 0x4A(SA0=L), 외부 32.768kHz 크리스털(CLKSEL0=GND)
[전원/USB] 보조배터리 USB-C 5V 입력 + ESP32-S3 네이티브 USB 업로드
[입력] 커넥터 핀순서 1=VCC 2=GND 3=SIG (A3144 핀순서와 동일). 스위치는 2-3번만 사용. MAG(J3)만 VCC=+5V (A3144 최소 4.5V, 오픈컬렉터라 3V3 풀업으로 안전)
확인 필요 (TODO) 1. BNO085 C5189642 JLC 재고 240개 — 발주 직전 재확인 2. BNO085 크리스털 부하캡 22pF: Adafruit 레퍼런스값 (데이터시트에 명시 없음, 12.5pF 크리스털 기준) 3. BNO085 ENV_SCL/SDA 풀업 10k: 데이터시트는 "풀업 필요"만 명시, 값 미지정 4. 진동모터 C2894723(3V 250mA) LCSC 재고 25개 — 예비 포함 2~3개 주문, 치수 확인. 5V 구동이므로 PWM 듀티 60% 이하 5. AMS1117 출력 세라믹 22uF 안정성: 데이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

Board: 2 copper layers, 50.0 x 30.0 mm, 49 parts (0 on the bottom side), 30 nets.

## Code that names these connections

File 자작 소총형 게임기/test_fw/bang_test/bang_test.ino:

// bang 보드 기능 점검 스케치 (ESP32-S3-WROOM-1, Arduino-ESP32)
// Tools 설정: Board = "ESP32S3 Dev Module", USB CDC On Boot = "Enabled"
// 시리얼 모니터 115200. 핀 번호는 PCB 배선 + ESP32-S3-WROOM-1 핀맵 기준.
#include <Wire.h>

const int PIN_TRIG     = 4;   // J2 방아쇠 (누르면 LOW)
const int PIN_MAG      = 5;   // J3 홀센서 (자석 오면 LOW)
const int PIN_BOLT     = 6;   // J4 노리쇠 (누르면 LOW)
const int PIN_RECENTER = 7;   // J5 리센터 (누르면 LOW)
const int PIN_SDA      = 8;   // BNO085 I2C
const int PIN_SCL      = 9;
const int PIN_IMU_INT  = 10;
const int PIN_IMU_RST  = 11;  // HIGH = 동작
const int PIN_MOTOR    = 12;  // 진동모터 PWM (Q1 게이트)
const int PIN_LED      = 13;  // D2 빨강 LED
const int BOOT_BTN     = 0;   // SW2 (누르면 LOW) -> 모터 테스트 버튼으로 사용

const int MOTOR_DUTY = 150;   // 0~255. 3V 모터를 5V로 돌리므로 약 59%로 제한

void i2cScan() {
  Serial.println("\n[I2C 스캔] BNO085는 0x4A가 떠야 정상");
  int found = 0;
  for (uint8_t a = 1; a < 127; a++) {
    Wire.beginTransmission(a);
    if (Wire.endTransmission() == 0) { Serial.printf("  발견: 0x%02X\n", a); found++; }
  }
  if (!found) Serial.println("  아무것도 없음 -> BNO085 납땜/전원/RST 확인");
}

void setup() {
  Serial.begin(115200);
  delay(1500);
  Serial.println("\n=== bang 보드 점검 시작 ===");

  pinMode(PIN_LED, OUTPUT);
  pinMode(PIN_MOTOR, OUTPUT); digitalWrite(PIN_MOTOR, LOW);
  pinMode(PIN_TRIG, INPUT); pinMode(PIN_MAG, INPUT);          // 보드에 10k 풀업 있음
  pinMode(PIN_BOLT, INPUT); pinMode(PIN_RECENTER, INPUT);
  pinMode(PIN_IMU_INT, INPUT_PULLUP);
  pinMode(BOOT_BTN, INPUT_PULLUP);

  // BNO085 리셋 해제
  pinMode(PIN_IMU_RST, OUTPUT);
  digitalWrite(PIN_IMU_RST, LOW);  delay(10);
  digitalWrite(PIN_IMU_RST, HIGH); delay(300);

  Wire.begin(PIN_SDA, PIN_SCL, 100000);
  i2cScan();
  Serial.println("\n입력 상태는 바뀔 때마다 출력. BOOT(SW2) 누르고 있으면 진동모터 동작.");
  Serial.println("시리얼에 's' 입력하면 I2C 재스캔.\n");
}

int last[5] = {-1,-1,-1,-1,-1};
const char* names[5] = {"TRIG(방아쇠)", "MAG(탄창)", "BOLT(노리쇠)", "RECENTER", "IMU_INT"};
const int pins[5] = {PIN_TRIG, PIN_MAG, PIN_BOLT, PIN_RECENTER, PIN_IMU_INT};

void loop() {
  static uint32_t t = 0;
  if (millis() - t > 500) { t = millis(); digitalWrite(PIN_LED, !digitalRead(PIN_LED)); }  // LED 깜빡임

  for (int i = 0; i < 5; i++) {
    int v = digitalRead(pins[i]);
    if (v != last[i]) {
      Serial.printf("%-14s : %s\n", names[i], v ? "HIGH (안 눌림/자석 없음)" : "LOW  (눌림/자석 감지)");
      last[i] = v;
    }
  }

  static bool motorOn = false;
  bool want = digitalRead(BOOT_BTN) == LOW;
  if (want != motorOn) {
    motorOn = want;
    analogWrite(PIN_MOTOR, motorOn ? MOTOR_DUTY : 0);
    Serial.println(motorOn ? "MOTOR ON" : "MOTOR OFF");
  }

  if (Serial.available() && Serial.read() == 's') i2cScan();
  delay(10);
}

## Commit log (part)

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2026-06-25 Add 돌쇠 베이스: offline Korean conversational AI (dolswe)
2026-06-26 Update 돌쇠 베이스 to 7ee1dd9 + learning data (memory)
2026-06-26 Update 돌쇠 베이스 to 06df4ac + learning data (memory, teach)
2026-06-26 Update 돌쇠 베이스 to 7b583fe + corrected teach data
2026-06-26 Update 돌쇠 베이스 to fc04505 (TTS crash fix, perspective, CORE memory)
2026-06-26 Update 돌쇠 베이스 to 4092433 (redact drop, no false hat)
2026-06-26 Update 돌쇠 베이스 to a417080 (code only, learning data excluded)
